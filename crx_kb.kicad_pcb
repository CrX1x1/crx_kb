File: crx_kb.kicad_pcb (KiCad board)
At the start: 2 copper layers, 91 parts

Commit message: Added KiCad submodule
Routing:
- net (no net): track 452.0 -> 549.4 mm, vias 26 -> 14
